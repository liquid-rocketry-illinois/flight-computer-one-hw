File: flight-computer-one.kicad_sch (KiCad schematic)
At the start: 8 parts, among them J1 LEFT_BANK, J2 RIGHT_BANK

Commit message: preliminary change to SAME51
Other:
- sheet Servos & Pyros ports: added PYRO1_DRAIN, PYRO2_DRAIN; removed none
Changed lines of the file:
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@@
 	(wire
 		(pts
-			(xy 173.99 149.86) (xy 233.68 149.86)
+			(xy 173.99 148.59) (xy 233.68 148.59)
 		)
 		(stroke
@@
 	(wire
 		(pts
+			(xy 121.92 166.37) (xy 137.16 166.37)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 184.15 43.18) (xy 184.15 52.07)
 		)
@@
 	(wire
 		(pts
+			(xy 214.63 157.48) (xy 233.68 157.48)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
+			(xy 214.63 154.94) (xy 233.68 154.94)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 223.52 118.11) (xy 233.68 118.11)
 		)
@@
 	(wire
 		(pts
-			(xy 210.82 91.44) (xy 210.82 144.78)
+			(xy 210.82 91.44) (xy 210.82 143.51)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 121.92 166.37) (xy 137.16 166.37)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 139.7 93.98) (xy 154.94 93.98)
 		)
@@
 	(wire
 		(pts
+			(xy 121.92 161.29) (xy 137.16 161.29)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 85.09 49.53) (xy 97.79 49.53)
 		)
@@
 	(wire
 		(pts
-			(xy 121.92 161.29) (xy 137.16 161.29)
-		)
-		(stroke
-			(width 0)
-			(type default)
-		)
-	)
-	(wire
-		(pts
 			(xy 179.07 31.75) (xy 179.07 33.02)
 		)
@@
 	(wire
 		(pts
-			(xy 210.82 144.78) (xy 233.68 144.78)
+			(xy 210.82 143.51) (xy 233.68 143.51)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 173.99 110.49) (xy 173.99 149.86)
+			(xy 173.99 110.49) (xy 173.99 148.59)
 		)
 		(stroke
@@
 			(width 0)
 			(type default)
+		)
+	)
+	(label "CANL"
+		(at 137.16 171.45 180)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right bottom)
+		)
+	)
+	(label "SERVO1_CTL"
+		(at 154.94 86.36 180)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right bottom)
+		)
+	)
+	(label "SERVO2_CTL"
+		(at 66.04 171.45 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
+		)
+	)
+	(label "SERVO4_CTL"
+		(at 66.04 176.53 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
+		)
+	)
+	(label "CANH"
+		(at 137.16 168.91 180)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right bottom)
+		)
+	)
+	(label "PYRO2_DRAIN"
+		(at 214.63 157.48 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
+		)
+	)
+	(label "GPIO40_ADC0"
+		(at 154.94 99.06 180)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right bottom)
 		)
 	)
@@
 		)
 	)
-	(label "CANL"
-		(at 137.16 171.45 180)
+	(label "CANH"
+		(at 223.52 118.11 0)
 		(effects
 			(font
 				(size 1.27 1.27)
 			)
-			(justify right bottom)
-		)
-	)
-	(label "SERVO1_CTL"
-		(at 154.94 86.36 180)
+			(justify left bottom)
+		)
+	)
+	(label "GPIO40_ADC0"
+		(at 137.16 176.53 180)
 		(effects
 			(font
@@
 		)
 	)
-	(label "SERVO2_CTL"
-		(at 66.04 171.45 0)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify left bottom)
-		)
-	)
-	(label "SERVO4_CTL"
-		(at 66.04 176.53 0)
+	(label "CANL"
+		(at 223.52 120.65 0)
 		(effects
 			(font
@@
 		)
 	)
-	(label "CANH"
-		(at 137.16 168.91 180)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify right bottom)
-		)
-	)
-	(label "GPIO40_ADC0"
-		(at 154.94 99.06 180)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify right bottom)
-		)
-	)
-	(label "CANH"
-		(at 223.52 118.11 0)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify left bottom)
-		)
-	)
-	(label "GPIO40_ADC0"
-		(at 137.16 176.53 180)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify right bottom)
-		)
-	)
-	(label "CANL"
-		(at 223.52 120.65 0)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify left bottom)
-		)
-	)
 	(label "SERVO4_CTL"
 		(at 154.94 93.98 180)
@@
 			)
 			(justify right bottom)
+		)
+	)
+	(label "PYRO1_DRAIN"
+		(at 214.63 154.94 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
 		)
 	)
@@
 	(sheet
 		(at 233.68 135.89)
-		(size 22.86 17.78)
+		(size 22.86 24.13)
 		(exclude_from_sim no)
 		(in_bom yes)
@@
 		)
 		(property "Sheetfile" "servo_pyro.kicad_sch"
-			(at 233.68 154.2546 0)
+			(at 233.68 160.6046 0)
 			(effects
 				(font
@@
 		)
 		(pin "BUZZER_CTL" input
-			(at 233.68 149.86 180)
+			(at 233.68 148.59 180)
 			(effects
 				(font
@@
 		)
 		(pin "I2C0_SCL" input
-			(at 233.68 144.78 180)
+			(at 233.68 143.51 180)
 			(effects
 				(font
@@
 			(effects
 				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+			)
+		)
+		(pin "PYRO1_DRAIN" input
+			(at 233.68 154.94 180)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(justify left)
+			)
+		)
+		(pin "PYRO2_DRAIN" input
+			(at 233.68 157.48 180)
+			(effects
+				(font

Commit message: same51 wired, near completion
Parts:
- renumbered R11 to R1, R12 to R2
Other:
- sheet Compute ports: added RXCAN, TXCAN; removed CS_CANXC
- sheet Connectivity ports: added RXCAN, TXCAN; removed CS_CANXC
- note added: "PBP = Protected Battery Power"
- note added: "Powering the pyros from +PBP instead of +BATT ensures that the pyro MOSFETs get RPP too, but it also theoretically allows you to light e-matches when the board is only powered from a USB port. Don't actually light e-matches with your laptop! Connect a high-value resistor to the pyro terminals instead."
- moved on the sheet: J1, J2
