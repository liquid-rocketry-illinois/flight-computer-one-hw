File: flight-computer-one.kicad_pcb (KiCad board)
At the start: 2 copper layers, 50 x 100 mm, 65 parts, among them J1 USB_C_Receptacle_USB2.0_16P, J2 Conn_Coaxial, J3 Screw_Terminal_01x08, J4 Screw_Terminal_01x08, J5 Conn_Coaxial, SW1 SW_Push, SW2 SW_Push, U1 RP2350_80QFN, U10 USBLC6-2SC6, U11 Ai-Thinker-Ra-01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

Commit message: created project lib
Parts:
- removed the J1 at (169.0, 62.1)
- added BZ1: Buzzer, Buzzer_Beeper:Buzzer_Mallory_AST1109MLTRQ, B.Cu at (147.0, 91.6)
- added G***: LOGO, LRI_partlib:rocketrin-withouteyes, B.Cu at (148.6, 60.4)
- added J3: USB_C_Receptacle_USB2.0_16P, Connector_USB:USB_C_Receptacle_GCT_USB4110, F.Cu at (125.6, 92.1)
- added J4: Micro_SD_Card_Det2, Connector_Card:microSD_HC_Hirose_DM3AT-SF-PEJM5, F.Cu at (161.3, 84.6)
- added TP1: TestPoint, TestPoint:TestPoint_Pad_D1.0mm, F.Cu at (86.5, 100.6)
- SW1: value SW_Push -> BOOTSEL
- SW2: value SW_Push -> USER
- U3: value W25Q32JVSS -> W25Q32JVZP; footprint Package_SO:SOIC-8_5.3x5.3mm_P1.27mm -> Package_SON:WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm
- moved R3 60.1 mm to (76.9, 93.2)
- moved C11 57.3 mm to (80.9, 68.8)
- moved C12 57.3 mm to (80.9, 71.3)
- moved C13 57.3 mm to (84.9, 58.7)
- moved C14 57.3 mm to (84.9, 61.2)
- moved C15 57.3 mm to (84.9, 63.7)
- moved C16 57.3 mm to (84.9, 66.2)
- moved C17 57.3 mm to (84.9, 68.8)
- moved C18 57.3 mm to (84.9, 71.3)
- moved C2 57.3 mm to (80.9, 58.7)
- moved C22 57.3 mm to (72.3, 60.1)
- moved C23 57.3 mm to (72.3, 62.7)
- moved C24 57.3 mm to (72.3, 65.2)
- moved C25 57.3 mm to (72.3, 67.7)
- moved C26 57.3 mm to (72.3, 70.2)
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- renumbered J3 to J1, J4 to J2, J2 to J6
Connections:
- C1 pad 1: VBUS -> +5V
- SW2 pad 2: /Compute/RUN -> unconnected-(SW2-Pad2)
- U10 pad 1: unconnected-(U10-I/O1-Pad1) -> /Power & USB/CONN_D+
- U10 pad 2: unconnected-(U10-GND-Pad2) -> GND
- U10 pad 3: unconnected-(U10-I/O2-Pad3) -> /Power & USB/CONN_D-
- U10 pad 4: unconnected-(U10-I/O2-Pad4) -> /Power & USB/USB_D-
- U10 pad 5: unconnected-(U10-VBUS-Pad5) -> VBUS
- U10 pad 6: unconnected-(U10-I/O1-Pad6) -> /Power & USB/USB_D+
- U2 pad 3: VBUS -> +5V
Other:
- copper layers 2 -> 4
- board text added: "COMM"
- board text added: "Flight Computer One Rev.A {dblquote}Electric Angel{dblquote}"
- board text added: "GNSS"

Commit message: added gitignore
Parts:
- removed C19, C5: 10u, Capacitor_SMD:C_0805_2012Metric
- removed the R1 at (84.1, 92.4)
- removed the U2 at (127.8, 114.6)
- added D1: PMEG4005CT, Package_TO_SOT_SMD:SOT-23, F.Cu at (136.8, 87.7)
- added J7: Conn_01x03_Pin, Connector_JST:JST_SH_BM03B-SRSS-TB_1x03-1MP_P1.00mm_Vertical, F.Cu at (145.6, 62.4)
- added Q1: CSD17318Q2, Package_SON:Texas_DQK, F.Cu at (129.3, 104.8)
- added Q2: CSD17318Q2, Package_SON:Texas_DQK, F.Cu at (129.3, 108.1)
- added Q3: CSD17318Q2, Package_SON:Texas_DQK, F.Cu at (129.3, 114.3)
- added Q4: CSD17318Q2, Package_SON:Texas_DQK, F.Cu at (129.3, 117.6)
- added Q5: CSD17318Q2, Package_SON:Texas_DQK, F.Cu at (144.3, 93.3)
- added R13: 100K, Resistor_SMD:R_0603_1608Metric, F.Cu at (76.8, 87.4)
- added R14: 100K, Resistor_SMD:R_0603_1608Metric, F.Cu at (147.8, 92.1)
- added R15: 100, Resistor_SMD:R_0603_1608Metric, F.Cu at (147.8, 94.6)
- added U11: TCAN3404-Q1, Package_SON:VSON-8-1EP_3x3mm_P0.65mm_EP1.65x2.4mm, F.Cu at (163.2, 111.4)
- BZ1: footprint Buzzer_Beeper:Buzzer_Mallory_AST1109MLTRQ -> Buzzer_Beeper:Buzzer_Murata_PKLCS1212E
- R1: renamed from R6; value 1k -> 1K; footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0603_1608Metric
- R10: value 0 -> 100; footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0603_1608Metric
- R2: value 1k -> 1K; footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0603_1608Metric
- R3, R7, R8: footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0603_1608Metric
- R4: value 1k -> 100K; footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0603_1608Metric
- R5: value 5k1 -> 5.1K
- R6: renamed from R13; value 5k1 -> 5.1K; footprint Capacitor_SMD:C_0603_1608Metric -> Resistor_SMD:R_0603_1608Metric
- R9: value DNF -> 100; footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0603_1608Metric
- U9: renamed from U11; value Ai-Thinker-Ra-01 -> Ai-Thinker-Ra-01H
- moved TP1 74.4 mm to (153.2, 67.6)
- moved J3 21.1 mm to (125.0, 71.0)
- moved R5 17.7 mm to (126.2, 63.2), turned to 180 degrees
- moved U10 17.3 mm to (131.9, 76.8)
- moved U8 7.59 mm to (137.7, 92.2)
- moved R9 6.51 mm to (89.2, 82.7)
- moved R10 5.42 mm to (89.2, 85.2)
- moved R6 4.67 mm to (126.4, 78.8), turned to 180 degrees
- moved G*** 4.41 mm to (147.0, 64.5)
- renumbered U3 to U2, U6 to U3, U9 to U6
Connections:
- BZ1 pad 1: +5V -> +3V3
- BZ1 pad 2: unconnected-(BZ1---Pad2) -> Net-(BZ1--)
- C1 pad 1: +5V -> VBUS
- J4 pad 1: unconnected-(J4-DAT2-Pad1) -> /Compute/DAT2
- J4 pad 10: unconnected-(J4-DET_A-Pad10) -> /Compute/CARD_DET
- J4 pad 2: unconnected-(J4-DAT3/CD-Pad2) -> /Compute/DAT3/CS
- J4 pad 3: unconnected-(J4-CMD-Pad3) -> /Compute/CMD/MOSI
- J4 pad 5: unconnected-(J4-CLK-Pad5) -> /Compute/SD_CLK
- J4 pad 7: unconnected-(J4-DAT0-Pad7) -> /Compute/DAT0/MISO
- J4 pad 8: unconnected-(J4-DAT1-Pad8) -> /Compute/DAT1
- J4 pad 9: unconnected-(J4-DET_B-Pad9) -> GND
- R10 pad 1: /Compute/QSPI_SS -> /Compute/SWDIO
- R10 pad 2: /Compute/FLASH_SS -> Net-(U1-SWD)
- R4 pad 1: Net-(R4-Pad1) -> +3V3
- R4 pad 2: GND -> Net-(R4-Pad2)
- R9 pad 1: /Compute/GPIO0 -> /Compute/SWCLK
- R9 pad 2: /Compute/FLASH_SS -> Net-(U1-SWCLK)
- SW2 pad 1: Net-(R4-Pad1) -> GND
- SW2 pad 2: unconnected-(SW2-Pad2) -> Net-(R4-Pad2)
- U1 pad 33: /Compute/SWCLK -> Net-(U1-SWCLK)
- U1 pad 34: /Compute/SWD -> Net-(U1-SWD)
- U2 pad 1: /Compute/FLASH_SS -> /Compute/QSPI_SS
Routing:
- added copper zone on B.Cu, net GND
- added copper zone on F.Cu, net GND
- added copper zone on In1.Cu, net GND
- added copper zone on In2.Cu, net GND

Commit message: Fixed BMI088 footprint and readme
Parts:
- removed D1: PMEG4005CT, Package_TO_SOT_SMD:SOT-23
- added U5: BMI088, LRI_partlib:QFN_BMI085_BOS, F.Cu at (128.2, 85.7)
Connections:
- U11 pad 9: (no net) -> GND

Commit message: progress, particularly on power
Parts:
- added C19: 22u, Capacitor_SMD:C_0805_2012Metric, F.Cu at (98.7, 115.1)
- added C30: 10u, Capacitor_SMD:C_0805_2012Metric, F.Cu at (90.6, 115.6)
- added C31: 100n, Capacitor_SMD:C_0603_1608Metric, F.Cu at (108.6, 111.9)
- added C5: 0.1u, Capacitor_SMD:C_0603_1608Metric, F.Cu at (93.3, 116.7)
- added FB1: 220R@100MHz, Inductor_SMD:L_0603_1608Metric, F.Cu at (110.9, 111.1)
- added Q5: CSD17318Q2, Package_SON:Texas_DQK, F.Cu at (96.6, 96.0)
- added Q6: CSD17318Q2, Package_SON:Texas_DQK, F.Cu at (96.7, 90.5)
- added R16: R_Shunt, Resistor_SMD:R_Shunt_Vishay_WSKW0612, F.Cu at (103.2, 92.2)
- added R17: 100K, Resistor_SMD:R_0603_1608Metric, F.Cu at (95.1, 113.1)
- added R18: 22.1K, Resistor_SMD:R_0603_1608Metric, F.Cu at (95.7, 115.4)
- added R19: 100K, Resistor_SMD:R_0603_1608Metric, F.Cu at (91.9, 113.1)
- added U12: INA232, LRI_partlib:TSOT-23-8, F.Cu at (107.3, 92.2)
- added U13: NCV68061, Package_TO_SOT_SMD:SOT-23-6, F.Cu at (93.2, 96.0)
- added U14: NCV68061, Package_TO_SOT_SMD:SOT-23-6, F.Cu at (93.3, 90.5)
- added U15: TPS561246, Package_TO_SOT_SMD:SOT-563, F.Cu at (93.4, 114.8)
- C1: value 10u -> 10n; footprint Capacitor_SMD:C_0805_2012Metric -> Capacitor_SMD:C_0603_1608Metric
- U2: value W25Q32JVZP -> W25Q32RVXHJQ; footprint Package_SON:WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4.3mm -> Package_SON:Winbond_USON-8-1EP_3x2mm_P0.5mm_EP0.2x1.6mm
- moved C27 78.3 mm to (154.1, 78.0)
- moved R9 59.1 mm to (143.9, 60.4), turned to -90 degrees
- moved R10 58.1 mm to (141.7, 60.4), turned to -90 degrees
- moved SW2 47.7 mm to (129.0, 89.0), turned to 90 degrees
- moved Q1 34.8 mm to (164.0, 108.0)
- moved Q3 34.8 mm to (163.9, 117.5)
- moved Q4 34.8 mm to (163.9, 120.8)
- moved Q2 34.8 mm to (163.9, 111.3)
- moved U11 34.6 mm to (128.6, 109.6)
- moved U4 34.6 mm to (128.5, 104.7)
- moved C1 29.2 mm to (108.6, 110.3)
- moved R2 27.3 mm to (177.9, 69.0)
- moved Y1 26.3 mm to (178.5, 71.5)
- moved C4 25.5 mm to (181.4, 71.5), turned to -90 degrees
- moved C3 22.2 mm to (177.9, 74.0)
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- renumbered Q5 to Q7
Connections:
- C1 pad 1: VBUS -> GND
- C1 pad 2: GND -> VBUS_RAW
- J3 pad A4: VBUS -> VBUS_RAW
- J3 pad A9: VBUS -> VBUS_RAW
- J3 pad B4: VBUS -> VBUS_RAW
- J3 pad B9: VBUS -> VBUS_RAW

Commit message: nearly completed schematic, partial layout
Parts:
- added C32: 1u, Capacitor_SMD:C_0603_1608Metric, F.Cu at (134.0, 106.3)
- added C33: 1u, Capacitor_SMD:C_0603_1608Metric, F.Cu at (131.7, 105.0)
- added C34: 1u, Capacitor_SMD:C_0603_1608Metric, F.Cu at (131.7, 103.4)
- added C35: 4.7u, Capacitor_SMD:C_0805_2012Metric, F.Cu at (138.3, 87.6)
- added C36: 0.1u, Capacitor_SMD:C_0603_1608Metric, F.Cu at (135.2, 83.2)
- added C37: 10n, Capacitor_SMD:C_0603_1608Metric, F.Cu at (138.1, 85.9)
- added U16: ICM-42688-P, LRI_partlib:IIM42352, F.Cu at (138.0, 82.8)
- added U17: ADS7138-Q1, Package_DFN_QFN:WQFN-16-1EP_3x3mm_P0.5mm_EP1.68x1.68mm_ThermalVias, F.Cu at (131.0, 108.0)
- added Y2: ASE-40.000MHz, Oscillator:Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm, F.Cu at (165.4, 107.3)
- BZ1: value Buzzer -> PKLCS1212E
- C31: value 100n -> 0.1u
- J5: value Conn_Coaxial -> GNSS u.FL
- J6: value Conn_Coaxial -> COMM u.FL
- moved C28 94.4 mm to (166.7, 74.4), turned to 90 degrees
- moved R4 67.5 mm to (145.8, 57.6)
- moved J7 48.1 mm to (147.1, 104.0), turned to 180 degrees
- moved R10 39.9 mm to (148.3, 99.7), turned to 90 degrees
- moved R9 39.4 mm to (146.1, 99.7), turned to 90 degrees
- moved SW2 38.8 mm to (145.5, 53.9)
- moved Q1 34.4 mm to (130.0, 113.0)
- moved Q2 34.4 mm to (129.9, 116.3)
- moved Q3 34.3 mm to (129.8, 121.0)
- moved Q4 34.3 mm to (129.8, 124.2)
- moved U4 34.2 mm to (162.7, 103.1), turned to 90 degrees
- moved U11 32.8 mm to (161.3, 108.2), turned to -90 degrees
- moved FB1 30.4 mm to (87.5, 91.7), turned to 0 degrees
- moved C31 30.3 mm to (88.2, 89.4), turned to -90 degrees
- moved C1 30.2 mm to (86.7, 89.4), turned to -90 degrees
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Connections:
- net Net-(J5-In) renamed /Connectivity/ANT_GNSS
- net Net-(J6-In) renamed /Connectivity/ANT_COMM
- net Net-(Q1-D-Pad1) renamed /Servos & Pyros/PYRO1_DRAIN
- net Net-(Q3-D-Pad1) renamed /Servos & Pyros/PYRO2_DRAIN
- C25 pad 1: unconnected-(C25-Pad1) -> GND
- C25 pad 2: unconnected-(C25-Pad2) -> +3V3
- C26 pad 1: unconnected-(C26-Pad1) -> +3V3
- C26 pad 2: unconnected-(C26-Pad2) -> GND
- C27 pad 1: unconnected-(C27-Pad1) -> GND
- C27 pad 2: unconnected-(C27-Pad2) -> +3V3
- C29 pad 1: unconnected-(C29-Pad1) -> Net-(U7-C1)
- C29 pad 2: unconnected-(C29-Pad2) -> GND
- J3 pad A6: /Power & USB/CONN_D- -> /Power & USB/CONN_D+
- J3 pad A7: /Power & USB/CONN_D+ -> /Power & USB/CONN_D-
- J3 pad B6: /Power & USB/CONN_D- -> /Power & USB/CONN_D+
- J3 pad B7: /Power & USB/CONN_D+ -> /Power & USB/CONN_D-
- U10 pad 1: /Power & USB/CONN_D+ -> /Power & USB/CONN_D-
- U10 pad 3: /Power & USB/CONN_D- -> /Power & USB/CONN_D+
- U10 pad 4: /Power & USB/USB_D- -> /Power & USB/USB_D+
- U10 pad 5: VBUS -> VBUS_RAW
- U10 pad 6: /Power & USB/USB_D+ -> /Power & USB/USB_D-
- U11 pad 1: unconnected-(U11-TXD-Pad1) -> Net-(U11-TXD)
- U11 pad 4: unconnected-(U11-RXD-Pad4) -> Net-(U11-RXD)
- U11 pad 6: unconnected-(U11-CANL-Pad6) -> /Connectivity/CANL
- U11 pad 7: unconnected-(U11-CANH-Pad7) -> /Connectivity/CANH
- U11 pad 8: unconnected-(U11-STB-Pad8) -> /Connectivity/TCAN_STB
- U12 pad 4: unconnected-(U12-VS-Pad4) -> +3V3
- U3 pad 1: Net-(U3-GND-Pad1) -> GND
- U3 pad 10: Net-(U3-GND-Pad1) -> GND
- U3 pad 12: Net-(U3-GND-Pad1) -> GND
- U3 pad 16: unconnected-(U3-SDA-Pad16) -> /Connectivity/I2C0_SDA
- U3 pad 17: unconnected-(U3-SCL-Pad17) -> /Connectivity/I2C0_SCL
- U3 pad 7: unconnected-(U3-VCC_IO-Pad7) -> +3V3
- U3 pad 8: unconnected-(U3-VCC-Pad8) -> +3V3
- U4 pad 1: unconnected-(U4-TXCAN-Pad1) -> Net-(U11-TXD)
- U4 pad 14: unconnected-(U4-VDD-Pad14) -> +3V3
- U4 pad 15: Net-(U4-VSS-Pad15) -> GND
- U4 pad 2: unconnected-(U4-RXCAN-Pad2) -> Net-(U11-RXD)
- U4 pad 6: unconnected-(U4-OSC1-Pad6) -> Net-(U4-OSC1)
- U4 pad 7: Net-(U4-VSS-Pad15) -> GND
- U7 pad 10: unconnected-(U7-Vdd_IO-Pad10) -> +3V3
- U7 pad 5: unconnected-(U7-C1-Pad5) -> Net-(U7-C1)
- U7 pad 9: unconnected-(U7-Vdd-Pad9) -> +3V3
- U9 pad 16: Net-(U9-GND-Pad16) -> GND
- U9 pad 2: Net-(U9-GND-Pad16) -> GND
- U9 pad 3: unconnected-(U9-VDD-Pad3) -> +3V3
- U9 pad 9: Net-(U9-GND-Pad16) -> GND
